# IAR project JamJar_1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: C:\Program Files (x86)\IAR Systems\Embedded Workbench 7.5\arm\CMSIS\Include; C:\TI-CMSIS-Devices-8636\TI\LM4F\Include; C:\ti\TivaWare_C_Series-2.1.3.156\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: cstartup_M.c main.c
    ../Project test/: LM4F120H5QR.h
    ../../../../../../ti/TivaWare_C_Series-2.1.3.156/inc/: tm4c123gh6pm.h
